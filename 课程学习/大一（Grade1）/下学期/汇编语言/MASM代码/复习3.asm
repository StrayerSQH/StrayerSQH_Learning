DATA SEGMENT
	NUM DB 45H, 35H, 20H
	MAXLEN DB 3
DATA ENDS

STACK1 SEGMENT STACK
	DB 40 DUP(0)
STACK1 ENDS

CODE SEGMENT
ASSUME CS:CODE, DS:DATA, SS:STACK1
BEGIN:
	MOV AX, DATA
	MOV DS, AX
	MOV ES, AX
	
	CALL PROC_
	
	MOV AH, 4CH
	INT 21H
	
PROC_:
	PUSH AX
	PUSH DX
	MOV CL, MAXLEN
	LEA SI, NUM
	LOP1:
		CLC
		MOV AL, [SI]
		AND AL, 01H
		JNZ L1
		JMP L2
	
	L1:
		MOV AH, [SI]
		OR AH, 0F0H
		MOV [SI], AH
	L2:
		INC SI
		LOOP LOP1
	
	POP DX
	POP AX
	RET
CODE ENDS
END BEGIN
