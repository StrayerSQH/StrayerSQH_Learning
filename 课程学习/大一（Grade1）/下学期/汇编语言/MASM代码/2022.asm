DATA SEGMENT
	ARR DB 0FFH, 0A2H, 23H, 56H, 1FH
	COUNT DB ?
	LEN EGU $-ARR
DATA ENDS

STACK SEGMENT
	DB 40 DUP(0)
STACK ENDS

CODE SEGMENT
ASSUME CS:CODE, SS:STACK, DS:DATA
BEGIN:
	MOV AX, DATA
	MOV AX, DS
	
	CALL COUNT_NUM	

	MOV AH, 4CH
	INT 21H

COUNT_NUM:
	PUSH AX
	PUSH DX
	LEA [SI], ARR
	MOV CL, LEN
	
S:
	MOV AL, [SI]
	NEG AL
	CMP AL, 10
	JB L1
	JMP L2

L1:
	INC COUNT
	DEC CL
	INC SI
	JMP S

L2:
	CMP AL, 20
	JA L1
	DEC CL
	INC SI
	JMP S
CODE ENDS
END BEGIN
	
