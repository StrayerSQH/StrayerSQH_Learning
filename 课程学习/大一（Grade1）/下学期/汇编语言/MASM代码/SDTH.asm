DATA SEGMENT
	STRING1 DW 'HE IS 35 YEARS OLD'
	STRING2 DW 40 DUP(0)
	LEN EQU $-STRING1
DATA ENDS

STACK SEGMENT
	DW 40 DUP(0)
STACK ENDS

CODE SEGMENT
ASSUME CS:CODE, DS:DATA, SS:STACK
BEGIN:MOV AX, DATA
	  MOV DS, AX
	  LEA SI, STRING1
	  LEA DI, STRING2
	  
	  CALL MOVNUMAWAY
	  
	  MOV AX, 4CH
	  INT 21H

MOVNUMAWAY:PUSH AX
		   PUSH DX
		   MOV CL, LEN
		   S:CMP [SI], 30h
		     JS L1
		     JMP L2
		   
		   POP DX
		   POP AX
		   RET
		   
L1:MOV AX, [SI]
   MOV [DI], AX
   JMP L5

L2:CMP [SI], 39H
   JS L5
   JMP L1

L5:INC SI
   INC DI
   LOOP S
CODE ENDS
END BEGIN     
